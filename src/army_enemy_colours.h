#ifndef ARMY_ENEMY_COLOURS_H
#define ARMY_ENEMY_COLOURS_H

// Material maps authored over the original 40x24 ink/mask drawings. They never
// replace silhouette bits. Level and tilted helicopter poses have separate
// maps; each pose shares its map across three rotor animation frames.
class ArmyEnemyColours {
public:
  static bool Colour(unsigned art,unsigned x,unsigned y,bool ink,unsigned &rgb) {
    unsigned pose;
    if(art>=0x7960 && art<=0x7e1a && (art-0x7960)%242==0)
      pose=(art-0x7960)/242<3?0:1;
    else if(art==0x80f0 || art==0x81e2)pose=2;
    else return false;
    if(x>=40 || y>=24)return false;
    // B body, G glass, R rotor/skid/bumper, T tail, A identification stripe,
    // C canvas and W wheel. Both INK and opaque PAPER get explicit colours.
    static const char *const materials[3][24]={
      {
        "BBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBB",
        "BBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBB",
        "BBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBB",
        "BBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBB",
        "BBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBB",
        "RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRBBBBBBBBB",
        "RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRBBBBBBBBB",
        "RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRBBBBBBBBB",
        "RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRBBBBBBBBT",
        "BBBBBBBBBBBBGGGGGGBBBBBBBBBBBBBBBBBBBTTT",
        "BBBBBBBBBGGGGGGGGBBBBBBBBBBBBBBBBBTTTTTT",
        "BBBBBBGGGGGGGGGGGBBBBBBBBBBBBBBBTTTTTTTT",
        "BBBBBGGGGGGGGGGGBBBBBBBBBBBBTTTTTTTTTTTT",
        "BBBBGGGGGGGGGGGGBBBBBBBTTTTTTTTTTTTTTTTT",
        "BBBGGGGGGGGGGGGBBBBBBBBBTTTTTTTTTTTTTTTT",
        "BBGGGGGGGGGGGGGBBBBBBBBBBTTTTTTTTTTTTTTT",
        "BBBBBBBBBBBBBBBBBAAAAAAAAATTTTTTTTTTTTTT",
        "BBBBBBBBBBBBBBBBBAAAAAAAAABTTTTTTTTTTTTT",
        "BBBBBBBBBBBBBBBBBAAAAAAAAABBBBBBBBBBBBBB",
        "BBBBBBBBBBBBBBBBBAAAAAAAAABBBBBBBBBBBBBB",
        "BBBRRRRRRRRRRRRRRRRRRBBBBBBBBBBBBBBBBBBB",
        "BBBRRRRRRRRRRRRRRRRRRBBBBBBBBBBBBBBBBBBB",
        "BBRRRRRRRRRRRRRRRRRRRRRRRRRRBBBBBBBBBBBB",
        "BBRRRRRRRRRRRRRRRRRRRRRRRRRRRBBBBBBBBBBB",
      },
      {
        "BBBBBBBBBBBBBBBBBBBBBBBBBRRRRRRBBBBBBBBB",
        "BBBBBBBBBBBBBBBBBBBBBBBRRRRRRBBBBBBBBBBT",
        "BBBBBBBBBBBBBBBBBBBBRRRRRRRBBBBBBBBBBBTT",
        "BBBBBBBBBBBBBBBBBBRRRRRRRBBBBBBBBBBBTTTT",
        "BBBBBBBBBBBBBBBRRRRRRRRBBBBBBBBBBBBTTTTT",
        "BBBBBBBBBBBBBRRRRRRRRBBBBBBBBBBBBTTTTTTT",
        "BBBBBBBBBBRRRRRGRRRBBBBBBBBBBBBBTTTTTTTT",
        "BBBBBBBBRRRRRGGGRBBBBBBBBBBBBTTTTTTTTTTT",
        "BBBBBRRRRRRGGGGGBBBBBBBBBBTTTTTTTTTTTTTT",
        "BBBRRRRRRGGGGGGBBBBBBBTTTTTTTTTTTTTTTTTT",
        "RRRRRRRRGGGGGGGBBBBTTTTTTTTTTTTTTTTTTTTT",
        "BRRRRRRGGGGGGGGBBBBBTTATTTTTTTTTTTTTTTTT",
        "BBBRRGGGGGGGGGGBBBBAAAATTTTTTTTTTTTTTTTT",
        "BBBBGGGGGGGGGGBBAAAAAAATTTTTTTTTTTTBBBBB",
        "BBBGGGGGGGGGGAAAAAAAAAAATTTTTTTBBBBBBBBB",
        "BBBGGGGGGGGBBBAAAAAAAAAABTRBBBBBBBBBBBBB",
        "BBBGGGGGGGBBBBAAAAAAABBRRRRRBBBBBBBBBBBB",
        "BBGGGGGGGBBBBBBAAAABRRRRRRRRRRBBBBBBBBBB",
        "BBGBBBBBBBBBBBBARRRRRRRRRRRBBBBBBBBBBBBB",
        "BBBBBBBBBBBBBRRRRRRRRRRRBBBBBBBBBBBBBBBB",
        "BBBBBBBBBBRRRRRRRRRRRBBBBBBBBBBBBBBBBBBB",
        "BBBBBBBRRRRRRRRRRRRBBBBBBBBBBBBBBBBBBBBB",
        "BBBBBBBBRRRRRRRRBBBBBBBBBBBBBBBBBBBBBBBB",
        "BBBBBBBBRRRRRBBBBBBBBBBBBBBBBBBBBBBBBBBB",
      },
      {
        "BBBBBBBBBBBBBBBBCCCCCCCCCCCCCCCCCCCCCCCC",
        "BBBBBBBBBBBBBBBBCCCCCCCCCCCCCCCCCCCCCCCC",
        "BBBBBBBBBBBBBBBBCCCCCCCCCCCCCCCCCCCCCCCC",
        "BBBBBBBBBBBBBBBBCCCCCCCCCCCCCCCCCCCCCCCC",
        "BBBBBBBBBBBBBBBBCCCCCCCCCCCCCCCCCCCCCCCC",
        "BBBBBBBBBBBBBBBBCCCCCCCCCCCCCCCCCCCCCCCC",
        "BBGGGGGGGGGGGGBBCCCCCCCCCCCCCCCCCCCCCCCC",
        "BBGGGGGGGGGGGGBBCCCCCCCCCCCCCCCCCCCCCCCC",
        "BGGGGGGGGGGGGGBBCCCCCCCCCCCCCCCCCCCCCCCC",
        "BGGGGGGGGGGGGGBBBBBCCCCCCCCCCCCCCCCCCCCC",
        "GGGGGGGGGGGGGGBBBBBBBCCCCCCCCCCCCCCCCCCC",
        "RRRRBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBB",
        "RRRRBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBBB",
        "RRRRWWWWWWWBBBBBBBBBBBBBBWWWWWWBBBBBBBBB",
        "RRRWWWWWWWWWBBBBBBBBBBBBWWWWWWWWBBBBBBBB",
        "RWWWWWWWWWWWWBBBBBBBBBWWWWWWWWWWWWBBBBBB",
        "RWWWWWWWWWWWWWBBBBBBBBWWWWWWWWWWWWWBBBBB",
        "RWWWWWWWWWWWWWBBBBBBBBWWWWWWWWWWWWWBBBBB",
        "BWWWWWWWWWWWWWBBBBBBBBWWWWWWWWWWWWWBBBBB",
        "BWWWWWWWWWWWWWBBBBBBBBWWWWWWWWWWWWWBBBBB",
        "BWWWWWWWWWWWWWBBBBBBBBWWWWWWWWWWWWWBBBBB",
        "BWWWWWWWWWWWWWBBBBBBBBWWWWWWWWWWWWWBBBBB",
        "BWWWWWWWWWWWWWBBBBBBBBWWWWWWWWWWWWWBBBBB",
        "BWWWWWWWWWWWWWBBBBBBBBWWWWWWWWWWWWWBBBBB",
      },
    };
    const char material=materials[pose][y][x];
    if(pose<2) {
      switch(material) {
        case 'G':rgb=ink?0xa1dbe2:0x25424e;break;
        case 'R':rgb=ink?0xb1bdc9:0x252e3b;break;
        case 'T':rgb=ink?0x8396b5:0x263044;break;
        case 'A':rgb=ink?0xe0ac65:0x56412e;break;
        default:rgb=ink?0x8ea3be:0x29394c;break;
      }
    } else {
      switch(material) {
        case 'G':rgb=ink?0xa1dbe2:0x25424e;break;
        case 'C':rgb=ink?0xc4af83:0x52483a;break;
        case 'W':rgb=ink?0x8f969e:0x141922;break;
        case 'R':rgb=ink?0xb3b8ba:0x30363b;break;
        default:rgb=ink?0xc67a65:0x58362f;break;
      }
    }
    return true;
  }
};
#endif
